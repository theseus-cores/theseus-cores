options:
  parameters:
    generate_options: qt_gui
    id: rfnoc_ddc_channelizer
    output_language: python
  states: {}

blocks:
- name: freq_0
  id: variable
  parameters:
    value: '-input_sine_freq'
  states: {}
- name: freq_1
  id: variable
  parameters:
    value: input_sine_freq
  states: {}
- name: input_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: input_sine_freq
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: lowpass_cutoff
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: output_rate_0
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: output_rate_1
  id: variable
  parameters:
    value: 25e3
  states: {}
- name: sine_offset
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: variable_ettus_device3_0
  id: variable_ettus_device3
  parameters:
    dev_addr: '"type=%s" % (device)'
    dev_args: ''
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '0.001'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_fastnoise_source_x_0_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1.0'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.1'
    freq: input_sine_freq
    offset: '0'
    phase: '0'
    samp_rate: input_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0.1'
    freq: '-input_sine_freq'
    offset: '0'
    phase: '0'
    samp_rate: input_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '0.01'
    freq: input_sine_freq+sine_offset
    offset: '0'
    phase: '0'
    samp_rate: input_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: input_rate
    type: complex
  states: {}
- name: device
  id: parameter
  parameters:
    label: Ettus Device Type
    value: x300
  states: {}
- name: ettus_rfnoc_streamer_fifo_0
  id: ettus_rfnoc_streamer_fifo
  parameters:
    block_index: '0'
    device_index: '-1'
    fpga_module_name: noc_block_axi_fifo_loopback
    grvlen: '1'
    otw: sc16
    type: fc32
  states: {}
- name: ettus_rfnoc_streamer_fifo_0_0
  id: ettus_rfnoc_streamer_fifo
  parameters:
    block_index: '1'
    device_index: '-1'
    fpga_module_name: noc_block_axi_fifo_loopback
    grvlen: '1'
    otw: sc16
    type: fc32
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: input_rate*lowpass_cutoff
    decim: '1'
    gain: '1'
    samp_rate: input_rate
    type: fir_filter_ccf
    width: input_rate*0.1
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: output_rate_0
    fc: freq_0
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@0
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: output_rate_1
    fc: freq_1
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@1
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: input_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0
    label0: Channel 0
    label1: Channel 1
    num_tabs: '2'
  states: {}
- name: theseus_rfnoc_ddc_1_to_n_0
  id: theseus_rfnoc_ddc_1_to_n
  parameters:
    block_index: '-1'
    device_index: '-1'
    enable_chans: '[True, True]'
    fpga_module_name: noc_block_ddc_1_to_n
    freq: '[-freq_0, -freq_1]'
    fullscale: '1.0'
    grvlen: '1'
    input_rate: input_rate
    num_chans: '2'
    otw: sc16
    output_rate: '[output_rate_0, output_rate_1]'
    type: fc32
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_fastnoise_source_x_0_0, '0', low_pass_filter_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '2']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_add_xx_0, '3']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_add_xx_0, '0', theseus_rfnoc_ddc_1_to_n_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '1']
- [blocks_throttle_0, '0', qtgui_sink_x_0_1, '0']
- [ettus_rfnoc_streamer_fifo_0, '0', qtgui_freq_sink_x_0, '0']
- [ettus_rfnoc_streamer_fifo_0_0, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_0_0, '0', blocks_multiply_xx_0, '0']
- [theseus_rfnoc_ddc_1_to_n_0, '0', ettus_rfnoc_streamer_fifo_0, '0']
- [theseus_rfnoc_ddc_1_to_n_0, '1', ettus_rfnoc_streamer_fifo_0_0, '0']

metadata:
  file_format: 1
