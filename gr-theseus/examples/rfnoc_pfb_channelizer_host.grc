options:
  parameters:
    generate_options: qt_gui
    id: rfnoc_pfb_channelizer
    output_language: python
  states: {}

blocks:
- name: decim_rate
  id: variable
  parameters:
    value: 200e6
  states: {}
- name: freq_0
  id: variable
  parameters:
    value: '-input_sine_freq'
  states: {}
- name: freq_1
  id: variable
  parameters:
    value: input_sine_freq
  states: {}
- name: in_vec_len
  id: variable
  parameters:
    value: '512'
  states: {}
- name: input_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: input_sine_freq
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: lowpass_cutoff
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: nchan
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200E6
  states: {}
- name: sine_offset
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: variable_ettus_device3_0
  id: variable_ettus_device3
  parameters:
    dev_addr: '"type=%s" % (device)'
    dev_args: args
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '0.001'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_fastnoise_source_x_0_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1.0'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.1'
    freq: input_sine_freq
    offset: '0'
    phase: '0'
    samp_rate: input_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0.1'
    freq: '-input_sine_freq'
    offset: '0'
    phase: '0'
    samp_rate: input_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '0.01'
    freq: input_sine_freq+sine_offset
    offset: '0'
    phase: '0'
    samp_rate: input_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: args
  id: parameter
  parameters:
    label: Ettus Args
    value: ''
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: theseus-chan-0.c32
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: theseus-chan-1.c32
    type: complex
  states: {}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: theseus-chan-2.c32
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_3
  id: blocks_file_sink
  parameters:
    file: theseus-chan-3.c32
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_4
  id: blocks_file_sink
  parameters:
    file: theseus-chan-4.c32
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_5
  id: blocks_file_sink
  parameters:
    file: theseus-chan-5.c32
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_6
  id: blocks_file_sink
  parameters:
    file: theseus-chan-6.c32
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_7
  id: blocks_file_sink
  parameters:
    file: theseus-chan-7.c32
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: in_vec_len
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: input_rate
    type: complex
  states: {}
- name: device
  id: parameter
  parameters:
    label: Ettus Device Type
    value: x300
  states: {}
- name: ettus_rfnoc_streamer_fifo_0
  id: ettus_rfnoc_streamer_fifo
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_axi_fifo_loopback
    grvlen: in_vec_len
    otw: sc16
    type: fc32
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: input_rate*lowpass_cutoff
    decim: '1'
    gain: '1'
    samp_rate: input_rate
    type: fir_filter_ccf
    width: input_rate*0.1
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_2
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: theseus_rfnoc_pfbchan_0
  id: theseus_rfnoc_pfbchan
  parameters:
    block_index: '-1'
    chan_idx: '[0,1,7]'
    device_index: '-1'
    fpga_module_name: noc_block_pfbchan
    num_chan: nchan
    vec_len_in: in_vec_len
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_fastnoise_source_x_0_0, '0', low_pass_filter_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '2']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_add_xx_0, '3']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '1']
- [blocks_stream_to_vector_0, '0', ettus_rfnoc_streamer_fifo_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_2, '0']
- [ettus_rfnoc_streamer_fifo_0, '0', theseus_rfnoc_pfbchan_0, '0']
- [low_pass_filter_0_0, '0', blocks_multiply_xx_0, '0']
- [theseus_rfnoc_pfbchan_0, '0', blocks_file_sink_0, '0']
- [theseus_rfnoc_pfbchan_0, '1', blocks_file_sink_1, '0']
- [theseus_rfnoc_pfbchan_0, '2', blocks_file_sink_7, '0']

metadata:
  file_format: 1
